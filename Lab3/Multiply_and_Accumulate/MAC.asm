// -- DO NOT CHANGE ANYTHING UNTIL THE **** LINE--//
ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL MAC
HERE: SJMP HERE
ORG 130H
// *****************
MAC:
// MAC OPERATION, CALL THE ADDITION SUBROUTINE USING "CALL ADD16"
MOV R0, #70H
MOV R1, #73H
MOV R3, #04H
MOV 52H, #00H
MOV 51H, #00H
MOV 50H, #00H
ACALL LOOP
RET


LOOP:
DJNZ R3, PRO
RET

PRO:
MOV A, @R0
MOV B, @R1
MUL AB
MOV R5, A
MOV R4, B
INC R0
INC R1
//MSB-LSB in R4-R5
ADD16:
// ADD16 SUBROUTINE FROM PREVIOUS LAB
CLR C
MOV A, R5
ADD A, 52H
MOV 52H, A
MOV A, R4
ADDC A, 51H
MOV 51H, A
MOV A,50H
ADDC A, #0H
MOV 50H, A
SJMP LOOP

END